FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://netcat.cfg"
