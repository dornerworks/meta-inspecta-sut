IMAGE_INSTALL_append = " ssh scp"
IMAGE_FEATURES_append = " allow-root-login"
