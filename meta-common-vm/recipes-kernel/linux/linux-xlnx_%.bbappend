SRC_URI += "file://virtio-net.scc"
SRC_URI += "file://config-va-bits.scc"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
