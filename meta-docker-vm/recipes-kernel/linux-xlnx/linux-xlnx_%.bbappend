FILESEXTRAPATHS_prepend := "${THISDIR}/cfg:"

SRC_URI_append = " file://docker.cfg"